options:
  parameters:
    author: Silvia Leon / Laura vilbao
    generate_options: qt_gui
    id: implementacion_promedio
    output_language: python
    title: Practica 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 2, -1, 3)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: '4'
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, N=4):  # <--- Asigna un número (ej. 4), NUNCA None
              gr.sync_block.__init__(
                  self,
                  name='Promedios_de_tiempos',
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]
              )
              self.N = N
              self.buffer = []
              
              self.val_media = 0.0
              self.val_m_cuad = 0.0
              self.val_rms = 0.0
              self.val_potencia = 0.0
              self.val_std = 0.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out_media, out_m_cuad, out_rms, out_potencia, out_std = output_items

              for sample in in0:
                  self.buffer.append(sample)
                  
                  if len(self.buffer) >= self.N:
                      arr = np.array(self.buffer)
                      
                      self.val_media = float(np.mean(arr))
                      self.val_m_cuad = float(np.mean(arr**2))
                      self.val_rms = float(np.sqrt(self.val_m_cuad))
                      self.val_potencia = float(self.val_m_cuad)
                      self.val_std = float(np.std(arr))
                      
                      self.buffer = []

              out_media[:] = self.val_media
              out_m_cuad[:] = self.val_m_cuad
              out_rms[:] = self.val_rms
              out_potencia[:] = self.val_potencia
              out_std[:] = self.val_std

              return len(in0)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media cuadratica
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: RMS
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencia promedio
    type: float
  states: {}
- name: qtgui_number_sink_3_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Deviacion estandar
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '1', qtgui_number_sink_1, '0']
- [epy_block_0, '1', qtgui_time_sink_x_0, '1']
- [epy_block_0, '2', qtgui_number_sink_2, '0']
- [epy_block_0, '2', qtgui_time_sink_x_0, '2']
- [epy_block_0, '3', qtgui_number_sink_3, '0']
- [epy_block_0, '3', qtgui_time_sink_x_0, '3']
- [epy_block_0, '4', qtgui_number_sink_3_0, '0']
- [epy_block_0, '4', qtgui_time_sink_x_0, '4']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
