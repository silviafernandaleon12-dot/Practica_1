options:
  parameters:
    generate_options: qt_gui
    id: diagrama_base
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 1, 1, 1, 1, 1, 1, 1, 1, 1)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # Hereda de sync_block
          """Bloque personalizado de Python para Comunicaciones II"""

          def __init__(self, factor=1.0):  # Parametro configurable desde GRC
              """Inicializacion del bloque"""
              gr.sync_block.__init__(
                  self,
                  name='Mi_Bloque_Python',   # Nombre que aparecera en el bloque
                  in_sig=[np.float32],       # Tipo de senal de entrada (Float 32)
                  out_sig=[np.float32]      # Tipo de senal de salida (Float 32)
              )
              self.factor = factor

          def work(self, input_items, output_items):
              """Procesamiento de muestras"""
              in0 = input_items[0]
              out = output_items[0]
              
              # Operacion sobre las muestras de entrada
              out[:] = in0 * self.factor
              
              return len(output_items[0])
    factor: '1.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
